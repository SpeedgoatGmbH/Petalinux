SRC_URI_append = " file://0001-net-macb-Add-MDIO-driver-for-accessing-multiple-PHY-.patch"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://user_2019-04-18-06-04-00.cfg"

